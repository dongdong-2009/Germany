# Keil uVision project RN821X.uvprojx, settings and files
target RN821X (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: RN8215 Renergy
  pack: Renergy.RN8XXX.1.0.0
  cpu: IRAM(0x10000000,0x4000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RN821X +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: uECC_OPTIMIZATION_LEVEL=3 uECC_ENABLE_VLI_API uECC_VLI_NATIVE_LITTLE_ENDIAN=1 uECC_SUPPORT_COMPRESSED_POINT=1
  c include: ./include;.\src\driver\SX1276
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x10000000 size 0x3800
  group include
    ./include/: nvm.h rtc.h sysctrl.h includes.h Drive_Lib.h sml.h
  group src
    ./src/: main.c
  group lib
    ./lib/: rn821x_nvm.lib rn821x_rtc.lib rn821x_sysctrl.lib
  group driver
    ./src/driver/: SystemInit.c system_RN8213.c Drive_Clock.c interrupt.c E2PROM.c Aes.c
    ./src/driver/micro-ecc/: uECC.c
    ./src/: startup_RN821x.s serial.c
  group app
    ./src/app/: Data.c Ram.c RsComm.c Time.c hdlc.c General.c Power.c
  group protocol
    ./src/protocol/: sml.c sym.c tls.c smlfunc.c iec1107_2.c
  group security
    C:/Keil_v5/ARM/PACK/ARM/mbedTLS/1.2.0/library/: base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c aesni.c asn1parse.c asn1write.c aes.c
